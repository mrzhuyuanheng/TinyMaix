## zephyr/Kconfig
```kconfig
# SPDX-License-Identifier: Apache-2.0

menuconfig TINY_MAIX
        bool "TINY_MAIX"
        default n
```
